# Repository michaellangford99/Indiana-Tech-Explorer-Post-2829-2017-Lightweight-Sumo

File README.md:

# Indiana-Tech-Explorer-Post-2829-2017-Lightweight-Sumo

## KiCad design PCB/Lightweight_Sumo.kicad_pcb

Parts:
C1, C2, C3, C4: C
D1: Green
D2: DIODE
D3: Red
D4, D5: LED
H1: Power Header
H2: IROut Back
H3: IRIn Front
H4: IROut Front
H5: Motor Header
H6: Programming Header
H7: LCD Header
H8: IRIn Back
H9: Kill_H1
H10: Kill_H2
H11: AUX1
H12: AUX2
H13: AUX3
H14: AUX4
H15: CONN_1
IC1: BS2P40
K1, K2: LM317
K3: LM7805
MJL_SW1: Power Switch
MJL_SW2, MJL_SW3: PushB
P1, P2, P3, P4, P5, P6, P7, P8: CONN_1
Q1, Q2, Q3, Q4: IRF3205L
R1: 170
R2, R4, R19: 220
R3, R5: 5K Bourns 32-66W
R6, R9, R10, R15, R16, R17, R18: 10K
R7, R8, R11, R12: 1K
R13, R14: 100K
SW1: SWITCH_INV_5-PIN
SW2: SPST

Connections:
+12V: D2.2 (K), H11.1, H12.1, H13.1, H14.1, K1.3, K2.3, K3.1, R1.1
+BATT: D3.1 (A), H1.2 (PM), MJL_SW1.2
D0: H9.6, IC1.24
D1: H9.8, IC1.23
D2: H9.10, IC1.22
D3: H9.11, IC1.21
Learn ACK: D5.1 (A), H9.7, SW2.1
unnamed: IC1.28, MJL_SW2.2, R9.2
unnamed: IC1.25, MJL_SW3.2, R10.1
unnamed: H7.3, IC1.36
unnamed: IC1.27, R13.2
unnamed: IC1.35, R6.2
unnamed: D1.1 (A), R1.2
unnamed: H12.2 (PM), Q2.1 (D)
unnamed: H11.2 (PM), Q1.1 (D)
unnamed: H14.2 (PM), Q4.1 (D)
unnamed: H2.1, K1.1, R2.1
unnamed: K1.2 (PM), R2.2, R3.2
unnamed: K2.2 (PM), R4.2, R5.2
unnamed: H4.1, K2.1, R4.1
unnamed: H5.2 (PM), IC1.13
unnamed: H5.1, IC1.14
unnamed: H2.7, IC1.19
unnamed: H1.3, R6.1
unnamed: H2.3, IC1.15
unnamed: H2.4, IC1.16
unnamed: H2.5, IC1.17
unnamed: H2.6, IC1.18
unnamed: D4.1 (A), R19.2
unnamed: H10.1, H15.1
unnamed: H13.2 (PM), Q3.1 (D)
unnamed: IC1.26, R14.2
unnamed: IC1.33, Q2.2 (G), R16.1
unnamed: IC1.32, Q3.2 (G), R17.1
unnamed: IC1.31, Q4.2 (G), R18.1
unnamed: D2.1 (A), MJL_SW1.4
unnamed: C4.1, H8.1, IC1.20, R8.2
unnamed: C1.1, H3.1, IC1.11, R7.2
unnamed: H4.3, IC1.6
unnamed: H4.4, IC1.7
unnamed: H4.5, IC1.8
unnamed: H4.6, IC1.9
unnamed: H4.7, IC1.10
unnamed: C2.1, H6.2, IC1.3
unnamed: H6.3, IC1.2
unnamed: H6.4, IC1.1
unnamed: IC1.34, Q1.2 (G), R15.1
unnamed: R12.2, R14.1, SW1.4
unnamed: R11.2, R13.1, SW1.2
unnamed: D3.2 (K), R11.1, R12.1
VDD: C3.2, D5.2 (K), H3.3, H7.2 (PM), H8.3, H9.3, IC1.37, K3.3, R7.1, R8.1, R9.1, R10.2
VSS: C1.2, C2.2, C3.1, C4.2, D1.2 (K), D4.2 (K), H1.1, H2.2, H3.2 (PM), H4.2, H6.1, H7.1, H8.2 (PM), H9.1, H10.2 (PM), IC1.4, IC1.39, K3.2 (PM), MJL_SW2.4, MJL_SW3.4, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R3.1, R5.1, R15.2, R16.2, R17.2, R18.2, SW1.3, SW2.2
VT: H9.5, R19.1

Board: 2 copper layers, 154.9 x 107.3 mm, 64 parts (0 on the bottom side), 53 nets.

## Commit log

2017-01-18 Added Experimental code folder for use with two sensored plows
2017-01-18 Added board images
2017-01-18 commented out dangerous Kill switch code
2017-01-18 Made minor comment revisions
2017-01-18 Made first revision of Search code for the new branch
2017-01-18 Modified IF statements, changed comments
2017-01-18 updated more IF statements, fixed improper comment
2017-01-18 Added Printed Circuit Board design files
2017-01-19 Working on adding Back sensor code - the header has also changed
2017-01-19 Completed first version of dual sensor code.
    Motor routines are still the same, but motor control code
    switches motor direction when in Back Sensor Mode
2017-01-19 Temporarily unused, will add back later
2017-01-19 Flipped <> characters
2017-01-19 Untracked .bak (backup) files, added them to .gitignore
2017-01-19 Fixed DEBUG printout of IR values
2017-01-19 Added weights to different sensor hits
    This makes the sumo change direction less readily
2017-01-20 Added SideBit to Scratch RAM
2017-01-20 Changed the way direction is switched
    A counter is increased when hits have been recieved on the opposite side
    and no hits are recieved on the current side. When the counter reaches a
    set max, the direction is changed and the counter is zeroed
2017-01-23 new Back-To-Back Charge routine, new reset code, gets direction from EEPROM
2017-01-23 new Back-To-Back routine
2017-01-23 Removed motor value flipping, made each direction's motor routines unique
2017-01-23 Added display routine that prints debug info to LCD
2017-03-02 added LED code
2017-03-02 Added test for front and back sensors
2017-03-02 Added hitcount to debug terminal, fixed some obvious errors, added some TODOs
2017-03-02 Updated display text for kill switch routine
2017-03-03 tidied up LED code, made IR Start work for both front and back sensors
2017-03-03 Added LED helper functions - kill switch code also turns on green LED
2017-03-31 fixing IRs
2017-03-31 added parentheses in IFs
2017-03-31 added comment for constant
2017-03-31 fixed sensor problems with pause in between sensor readings
2017-04-01 reduced code size, fixed direction bit error, created uniform variable space, fixed pin problems
2018-01-24 fixed spelling error in comment, added call to sensors in Kill, put IR constants at top
2018-01-24 1st revision operating PID loop with side switching
2018-01-24 backups
2018-01-24 Completed 1st revision full PID loop code
2018-01-26 Added GOSUB Kill to allow killing robot while armed, fixed BB180Charge debug
2018-01-26 Added code to initially blind sensors at start of routine to prevent IR remote from forcing it out of start routine also tuned routines
2018-01-26 improved tuneability of search code using constant
2018-01-26 new test code for LEDs, plus PID loop test code
2018-01-26 added comment to explain reasoning behind initial blinding of sensors during start routine
2018-01-28 renamed file for new year
2018-04-07 Renamed start routines, enabled IR Start, added EEPROM write functionality for program switches, trimmed LCD display function
